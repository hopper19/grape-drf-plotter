options:
  parameters:
    author: rvolz
    generate_options: no_gui
    id: drf_read_example
    output_language: python
    run_options: run
    title: Digital RF s16 with 3 subchannels example
  states: {}

blocks:
- name: cfreq_0
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: cfreq_1
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: cfreq_2
  id: variable
  parameters:
    value: 15e6
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '800'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(samp_rate)
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.02'
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: (2**15 - 1)
    vlen: '3'
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: '3'
    type: complex
    vlen: '3'
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    limit: time
    maximum: 1.0 / 40
    samples_per_second: 10 * samp_rate
    type: float
  states: {state: disabled}
- name: blocks_vector_to_streams_0_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: '3'
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /home/cuong/code/GrapeDRFPlotting/wav/w2naf-grape2-channel1.wav
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {state: disabled}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: cfreq_1
    freq_span: samp_rate
    gui_hint: tabs@3
  states: {state: disabled}
- name: gr_digital_rf_digital_rf_channel_sink_0_0
  id: gr_digital_rf_digital_rf_channel_sink
  parameters:
    center_freqs: '[5.0]'
    checksum: 'False'
    compression_level: '1'
    debug: 'False'
    dir: output/grape2DRF/w2naf/OBS2024-04-08
    file_cadence_ms: '180000'
    ignore_tags: 'False'
    input: fc32
    is_continuous: 'True'
    marching_periods: 'True'
    metadata: '{''lat'':41.33,''long'':-75.67}'
    min_chunksize: '0'
    sample_rate_denominator: '1'
    sample_rate_numerator: int(samp_rate/decimation)
    start: '''2024-04-08T00:00:00Z'''
    stop_on_skipped: 'False'
    stop_on_time_tag: 'False'
    subdir_cadence_s: '3600'
    uuid: ''
    vlen: '1'
  states: {}
- name: gr_digital_rf_digital_rf_channel_sink_0_0_0
  id: gr_digital_rf_digital_rf_channel_sink
  parameters:
    center_freqs: '[5.0]'
    checksum: 'False'
    compression_level: '1'
    debug: 'False'
    dir: get_datetime.output
    file_cadence_ms: '180000'
    ignore_tags: 'False'
    input: fc32
    is_continuous: 'True'
    marching_periods: 'True'
    metadata: '{''lat'':33.396,''long'':-87.542}'
    min_chunksize: '0'
    sample_rate_denominator: '1'
    sample_rate_numerator: int(samp_rate/decimation)
    start: get_datetime.dt* (samp_rate/(10*decimation))
    stop_on_skipped: 'False'
    stop_on_time_tag: 'False'
    subdir_cadence_s: '3600'
    uuid: grape19
    vlen: '1'
  states: {state: disabled}
- name: gr_digital_rf_digital_rf_sink_0
  id: gr_digital_rf_digital_rf_sink
  parameters:
    center_freqs: '[]'
    channel0: ch0
    checksum: 'False'
    compression_level: '0'
    debug: 'False'
    file_cadence_ms: '1000'
    ignore_tags: 'False'
    input: fc32
    is_continuous: 'True'
    marching_periods: 'True'
    metadata: '{}'
    min_chunksize: '0'
    nchan: '1'
    sample_rate_denominator: '1'
    sample_rate_numerator: int(samp_rate)
    start: ''
    stop_on_skipped: 'False'
    stop_on_time_tag: 'False'
    subdir_cadence_s: '3600'
    top_level_dir: ''
    uuid: ''
    vlen: '1'
  states: {state: disabled}
- name: gr_digital_rf_digital_rf_source_0
  id: gr_digital_rf_digital_rf_source
  parameters:
    channel0: ch0
    end0: ''
    gapless: 'True'
    hide_msg_port: 'True'
    min_chunksize: '0'
    nchan: '1'
    repeat: 'False'
    start0: ''
    throttle: 'False'
    top_level_dir: /home/cuong/code/GrapeDRFPlotting/data/psws_grape2DRF/w2naf/
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '512'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '50'
    decim: decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '5'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '512'
    gui_hint: tabs@1
    label1: f"{cfreq_0/1e6} MHz"
    label2: f"{cfreq_1/1e6} MHz"
    label3: f"{cfreq_2/1e6} MHz"
    nconnections: '3'
    type: float
    update_time: '0.05'
    ymax: '0'
    ymin: '-80'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color3: cyan
    ctrlpanel: 'True'
    gui_hint: tabs@2
    label1: f"{cfreq_0/1e6} MHz"
    label2: f"{cfreq_1/1e6} MHz"
    label3: f"{cfreq_2/1e6} MHz"
    nconnections: '3'
    size: int(samp_rate / 20)
    srate: samp_rate
    type: float
    update_time: '.01'
    ymax: '1.2'
    ymin: '-1.2'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    color1: '1'
    fc: cfreq_0
    fftsize: '512'
    gui_hint: tabs@0
    int_max: '0'
    int_min: '-80'
    type: float
    update_time: '0.05'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    color1: '1'
    fc: cfreq_1
    fftsize: '512'
    gui_hint: tabs@0
    int_max: '0'
    int_min: '-80'
    type: float
    update_time: '0.05'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    color1: '1'
    fc: cfreq_2
    fftsize: '512'
    gui_hint: tabs@0
    int_max: '0'
    int_min: '-80'
    type: float
    update_time: '0.05'
  states: {state: disabled}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Waterfall
    label1: Spectrum
    label2: Time series
    label3: Fosphor
    num_tabs: '4'
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_float_to_complex_0, '0', fosphor_qt_sink_c_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [blocks_short_to_float_0, '0', blocks_vector_to_streams_0_0, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']
- [blocks_vector_to_streams_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_vector_to_streams_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_vector_to_streams_0_0, '0', blocks_throttle2_0, '0']
- [blocks_vector_to_streams_0_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_vector_to_streams_0_0, '0', hilbert_fc_0, '0']
- [blocks_vector_to_streams_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vector_to_streams_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_to_streams_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_vector_to_streams_0_0, '1', blocks_null_sink_1, '0']
- [blocks_vector_to_streams_0_0, '1', qtgui_freq_sink_x_0, '1']
- [blocks_vector_to_streams_0_0, '1', qtgui_time_sink_x_0, '1']
- [blocks_vector_to_streams_0_0, '1', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_vector_to_streams_0_0, '2', blocks_null_sink_2, '0']
- [blocks_vector_to_streams_0_0, '2', qtgui_freq_sink_x_0, '2']
- [blocks_vector_to_streams_0_0, '2', qtgui_time_sink_x_0, '2']
- [blocks_vector_to_streams_0_0, '2', qtgui_waterfall_sink_x_0_1, '0']
- [gr_digital_rf_digital_rf_source_0, '0', blocks_short_to_float_0, '0']
- [hilbert_fc_0, '0', blocks_multiply_xx_0, '0']
- [low_pass_filter_0, '0', gr_digital_rf_digital_rf_channel_sink_0_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0

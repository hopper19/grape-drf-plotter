options:
  parameters:
    author: cnguyen,rvolz
    generate_options: no_gui
    id: drf_downsampler
    output_language: python
    run_options: run
    thread_safe_setters: '1'
    title: Downsampling Grape2 8kHz bandwidth Digital RF data to 10kHz bandwidth
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '800'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: (2**15 - 1)
    vlen: '3'
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: '3'
    type: complex
  states: {}
- name: blocks_vector_to_streams_0_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: '3'
    type: float
  states: {}
- name: gr_digital_rf_digital_rf_sink_0
  id: gr_digital_rf_digital_rf_sink
  parameters:
    center_freqs: '[5,10,15]'
    channel0: ch0
    checksum: 'False'
    compression_level: '0'
    debug: 'False'
    file_cadence_ms: '180000'
    ignore_tags: 'False'
    input: fc32
    is_continuous: 'True'
    marching_periods: 'False'
    metadata: '{''lat'':None,''long'':None}'
    min_chunksize: '0'
    nchan: '1'
    sample_rate_denominator: '1'
    sample_rate_numerator: int(samp_rate/decimation)
    start: '''2024-04-08T00:00:00Z'''
    stop_on_skipped: 'False'
    stop_on_time_tag: 'False'
    subdir_cadence_s: '3600'
    top_level_dir: out_drf
    uuid: ''
    vlen: '3'
  states: {}
- name: gr_digital_rf_digital_rf_source_0
  id: gr_digital_rf_digital_rf_source
  parameters:
    channel0: ch0
    end0: ''
    gapless: 'True'
    hide_msg_port: 'True'
    min_chunksize: '0'
    nchan: '1'
    repeat: 'False'
    start0: ''
    throttle: 'False'
    top_level_dir: source_drf
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '512'
  states: {}
- name: hilbert_fc_0_0
  id: hilbert_fc
  parameters:
    num_taps: '512'
  states: {}
- name: hilbert_fc_0_1
  id: hilbert_fc
  parameters:
    num_taps: '512'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '50'
    decim: decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '5'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '50'
    decim: decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '5'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '50'
    decim: decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '5'
    win: window.WIN_HAMMING
  states: {}
- name: out_drf
  id: parameter
  parameters:
    label: Address for the output Digital RF directory
    short_id: o
    type: str
    value: output/grape2DRF/w2naf/OBS2024-04-08T00-00
  states: {}
- name: source_drf
  id: parameter
  parameters:
    label: Address of the 8kHz bandwidth source Digital RF directory
    short_id: d
    type: str
    value: /home/cuong/G2DATA/Sdrf/OBS2024-04-08T00-00/
  states: {}

connections:
- [blocks_short_to_float_0, '0', blocks_vector_to_streams_0_0, '0']
- [blocks_streams_to_vector_0, '0', gr_digital_rf_digital_rf_sink_0, '0']
- [blocks_vector_to_streams_0_0, '0', hilbert_fc_0, '0']
- [blocks_vector_to_streams_0_0, '1', hilbert_fc_0_0, '0']
- [blocks_vector_to_streams_0_0, '2', hilbert_fc_0_1, '0']
- [gr_digital_rf_digital_rf_source_0, '0', blocks_short_to_float_0, '0']
- [hilbert_fc_0, '0', low_pass_filter_0, '0']
- [hilbert_fc_0_0, '0', low_pass_filter_0_0, '0']
- [hilbert_fc_0_1, '0', low_pass_filter_0_1, '0']
- [low_pass_filter_0, '0', blocks_streams_to_vector_0, '0']
- [low_pass_filter_0_0, '0', blocks_streams_to_vector_0, '1']
- [low_pass_filter_0_1, '0', blocks_streams_to_vector_0, '2']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
